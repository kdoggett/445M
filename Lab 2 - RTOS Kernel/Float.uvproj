# Keil uVision project Float.uvproj, settings and files
target Float (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Float
  c flags: Optim=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Code
    ./: Lab2.c cr4_fft_64_stm32.s PID_stm32.s ADC.c ST7735.c UART.c OS.c PLL.c startup.s
